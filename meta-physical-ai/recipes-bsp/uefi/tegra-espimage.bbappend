# Match the custom NVMe partition layout's 2 GiB ESP / esp_alt partitions.
IMAGE_ROOTFS_SIZE:jetson-orin-nano-devkit-nvme = "2097152"
IMAGE_ROOTFS_MAXSIZE:jetson-orin-nano-devkit-nvme = "2097152"
